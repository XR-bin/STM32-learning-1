# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c include: ..\SYSTEM\sys;..\SYSTEM\delay;..\HARDWARE\inc;..\SYSTEM\usart;..\SYSTEM\nvic;..\SYSTEM\exti
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: startup_stm32f10x_hd.s test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/nvic/: nvic.c
    ../SYSTEM/exti/: exti.c
  group HARDWARE
    ../HARDWARE/src/: led.c beep.c key.c iic.c at24cxx.c lcd.c font.c spi.c w25q128.c touch.c adc.c time.c pwm.c capture.c dma.c rtc.c fsmc.c iwdg.c can.c OLED.c matrix.c
  group README
    ./ReadMe/: ReadMe.txt
