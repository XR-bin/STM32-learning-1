# Keil uVision project STM32F407ZGT6.uvprojx, settings and files
target M4 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407ZGT6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F407xx
  c include: ..\..\Drivers;..\..\Drivers\BSP;..\..\Drivers\BSP\inc;..\..\Drivers\Libraries;..\..\Drivers\SYSTEM;..\..\Drivers\SYSTEM\inc;..\..\User;..\..\User\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Drivers/Libraries/arm/: startup_stm32f407xx.s
  group User
    ../../User/: main.c
  group System
    ../../Drivers/SYSTEM/src/: sys.c delay.c usart.c
  group BSP
    ../../Drivers/BSP/src/: fsmc.c lcd.c spi.c w25q128.c show.c
