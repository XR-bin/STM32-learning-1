# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\SYSTEM\sys;..\USER;..\SYSTEM\usart;..\SYSTEM\nvic;..\SYSTEM\exti;..\SYSTEM\delay;..\HARDWARE\inc;..\SYSTEM\time
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../SYSTEM/sys/: system_stm32f4xx.c
    ./: startup_stm32f40_41xxx.s test.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/nvic/: nvic.c
    ../SYSTEM/exti/: exit.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/time/: time.c
  group HARDWARE
    ../HARDWARE/src/: beep.c led.c key.c iic.c at24cxx.c lcd.c font.c spi.c w25q64.c touch.c adc.c pwm.c capture.c dma.c rtc.c fsmc.c iwdg.c can.c OLED.c matrix.c
  group README
    ./ReadMe/: ReadMe.txt
